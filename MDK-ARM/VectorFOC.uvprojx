# Keil uVision project VectorFOC.uvprojx, settings and files
target VectorFOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: VectorFOC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Lib/Core/Inc;../Lib/Drivers/STM32G4xx_HAL_Driver/Inc;../Lib/Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Lib/Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Lib/Drivers/CMSIS/Include;../Lib/Middlewares/ST/ARM/DSP/Inc;../Lib/USB_Device/App;../Lib/USB_Device/Target;../Lib/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Lib/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Src/APP;../Src/APP/init;../Src/APP/rtos;../Src/APP/isr;../Src/HAL/interface;../Src/HAL/stm32g4;../Src/HAL/bsp;../Src/HAL/encoder;../Src/ALGO;../Src/ALGO/motor;../Src/ALGO/control;../Src/ALGO/foc;../Src/ALGO/pid;../Src/ALGO/observer;../Src/ALGO/trajectory;../Src/COMM;../Src/COMM/manager;../Src/COMM/executor;../Src/COMM/protocol;../Src/COMM/protocol/canopen;../Src/COMM/protocol/inovxio;../Src/COMM/protocol/mit;../Src/COMM/transport;../Src/UI;../Src/UI/parameter;../Src/UI/led;../Src/UI/vofa;../Src/UI/error;../Lib/Middlewares/Third_Party/FreeRTOS/Source/include;../Lib/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Lib/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Lib/Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Lib/Core/Src/: main.c gpio.c app_freertos.c adc.c crc.c dma.c fdcan.c rng.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Lib/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_rng.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Lib/Core/Src/: system_stm32g4xx.c
  group Application/User/USB_Device/Target
    ../Lib/USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../Lib/USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Middlewares/USB_Device_Library
    ../Lib/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Lib/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group APP
    ../Src/APP/init/: app_init.c
    ../Src/APP/isr/: isr_foc.c
    ../Src/APP/rtos/: cmd_service.c task_comm.c task_debug.c task_guard.c
  group HAL
    ../Src/HAL/bsp/: bsp_adc.c bsp_flash.c bsp_dwt.c bsp_can.c bsp_log.c bsp_usart.c can_transport.c
    ../Src/HAL/encoder/: mt6816_encoder.c
    ../Src/HAL/stm32g4/: hal_abstraction.c hal_adc.c hal_encoder.c hal_pwm.c motor_adc.c motor_hal_g431.c
  group ALGO
    ../Src/ALGO/pid/: pid.c
    ../Src/ALGO/foc/: clarke.c park.c svpwm.c foc_algorithm.c trigonometry.c
    ../Src/ALGO/observer/: smo_observer.c
    ../Src/ALGO/trajectory/: trap_traj.c rate_limiter.c
    ../Src/ALGO/control/: control.c impl.c inner.c outer.c cogging.c feedforward.c field_weakening.c
    ../Src/ALGO/motor/: motor.c motor_data.c motor_api.c fsm.c safety_control.c fault_detection.c fault_def.c calib_encoder.c calib_resistance.c calib_inductance.c flux_calib.c current_calib.c rsls_calib.c calibration_context.c
  group COMM
    ../Src/COMM/manager/: manager.c
    ../Src/COMM/executor/: executor.c
    ../Src/COMM/protocol/inovxio/: inovxio_protocol.c
    ../Src/COMM/protocol/canopen/: canopen_protocol.c
    ../Src/COMM/protocol/mit/: mit_protocol.c
  group UI
    ../Src/UI/led/: led.c
    ../Src/UI/vofa/: vofa.c
    ../Src/UI/error/: error_manager.c
    ../Src/UI/parameter/: param_access.c param_storage.c param_table.c
  group Middlewares/FreeRTOS
    ../Lib/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Lib/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Lib/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Lib/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Lib/Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.6.0
