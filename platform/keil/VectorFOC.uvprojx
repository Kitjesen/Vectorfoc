# Keil uVision project VectorFOC.uvprojx, settings and files
target VectorFOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x200057EF) IROM(0x8004000-0x801EFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: VectorFOC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,HSE_VALUE=8000000U
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../USB_Device/App;../USB_Device/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../src/config;../../src/app;../../src/hal;../../src/hal/bsp;../../src/hal/encoder;../../src;../../src/motor;../../src/safety;../../src/foc;../../src/foc;../../src/comm;../../src/config;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1b000
  memory RVCT9: RAM 0x20000000 size 0x57f0
  group Application/MDK-ARM
    ../: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c dma.c fdcan.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_dma.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_spi.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group src/app
    ../../src/app/: application_init.c foc_isr.c communication_task.c diagnostics_task.c safety_task.c status_led.c
  group algorithm
    ../../algorithm/: foc_current_loop.c foc_transforms.c field_weakening.c torque_feedforward.c ladrc_controller.c pid_controller.c command_limiter.c sliding_mode_observer.c trapezoid_trajectory.c
  group src/foc
    ../../src/foc/: control_dispatcher.c runtime_compensation.c outer_control.c cogging_compensation.c
    ..//..//src//foc//: observer_adapter.c
  group src/motor
    ../../src/motor/: motor_runtime.c motor_defaults.c drive_state_machine.c encoder_calibration.c flux_calibration.c current_calibration.c resistance_inductance_calibration.c calibration_state.c
  group src/safety
    ../../src/safety/: safety_manager.c fault_monitor.c fault_definition.c error_manager.c
  group src/comm
    ../../src/comm/: protocol_dispatcher.c command_executor.c protocol_vector.c protocol_canopen.c protocol_mit.c telemetry_vofa.c
  group src/config
    ../../src/config/: parameter_access.c parameter_storage.c parameter_registry.c
  group src/hal
    ../../src/hal/bsp/: board_adc.c board_flash.c board_cycle_counter.c board_can.c board_log.c
    ../../src/hal/encoder/: mt6816_encoder.c
    ../../src/hal/: hardware_interface.c encoder_interface.c pwm_interface.c motor_sampling.c
  group Integration modules
    ../../src/app/: application_header.c
    ../../src/boot/: bootloader.c
    ../../src/config/: encoder_calibration_settings.c encoder_calibration_storage.c parameter_bindings.c runtime_settings.c
    ../../src/hal/encoder/: position_sensor_mt6816.c position_sensor_selection.c position_sensor_tmr3109.c position_sensor.c tmr3109_encoder.c
    ../../src/hal/: system_calls.c
    ../../src/safety/: adc_sample_guard.c encoder_failure_guard.c watchdog_supervisor.c
software components: CMSIS:CORE 5.6.0
